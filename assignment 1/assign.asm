 AREA PROGRAM, CODE, READONLY
 ENTRY
MAIN
	 MOV R0, #1
	 MOV R1, #2
	 MOV R2, R1
	 CMP R1, R2
	 BEQ LOOP1 ; EQUAL
LOOP6
	 ADD R0,R0,#1
	 LDR R1, =0X70FFFFFF
	 LDR R2, =0X3FFFFFFF
	 ADDS R2, R1, R2
	 BVS LOOP7 ; OVERFLOW
LOOP1 
	 ADD R0, R0, #1
	 MOV R1, #1
	 MOV R2, #2
	 CMP R1, R2
	 BNE LOOP2 ; NOT EQUAL
LOOP4
	 ADD R0,R0,#1
	 MOV R1, #1
	 MOV R2, #3
	 SUBS R1, R1, R2
	 BMI LOOP5 ; MINUS
LOOP3
	 ADD R0,R0,#1
	 LDR R1, =0x00001000
	 ADDS R1, R1, R1
	 BCC LOOP4 ; CARRY CLEAR
LOOP2
	 ADD R0, R0, #1
	 LDR R1, =0xFFFFFFFF
	 ADDS R1, R1, R1
	 BCS LOOP3 ; CARRY SET
LOOP5
	 ADD R0,R0,#1
	 MOV R1, #5
	 MOV R2, #2
	 SUBS R1, R1, R2
	 BPL LOOP6 ; POSITIVE
LOOP9
	 ADD R0,R0,#1
	 MOV R1, #1
	 MOV R2, #2
	 CMP R2, R1
	 BGT LOOP10 ; GREATER THAN
LOOP8
	 ADD R0, R0, #1
	 MOV R1, #1
	 MOV R2, #2
	 CMP R1, R2
	 BLT LOOP9 ; LESS THAN
LOOP12
	 ADD R0,R0,#1
	 CMP R1 , R2
	 BLS LOOP13 ;UNSIGNED LOWER OR SAME
LOOP11
	 ADD R0,R0,#1
	 CMP R1, R2
	 BLE LOOP12 ; less or equal
LOOP10
	 ADD R0, R0, #1
	 MOV R1, R2
	 BGE LOOP11 ; GREATER OR EQUAL

LOOP14
	 ADD R0,R0,#1
	 BAL LOOP20 ; ALWAYS
LOOP13
	 ADD R0,R0,#1
	 LDR R1,=0XFFFF0000
	 MOV R2,R1
	 ADDS R1, R1, R2
	 BHI LOOP14 ; UNSIGNED HIGHER
LOOP7
	 ADD R0,R0,#1
	 LDR R1, =0X00001000
	 LDR R2, =0x00000000
	 ADDS R1, R1, R2
	 BVC LOOP8 ; NO OVERFLOW 
LOOP20 B LOOP20
 END